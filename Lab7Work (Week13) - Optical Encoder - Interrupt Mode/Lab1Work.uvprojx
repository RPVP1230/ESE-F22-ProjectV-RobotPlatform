# Keil uVision project Lab1Work.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1Work
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: LED.c LED.h main.c startup_stm32f303xe.s system_stm32f3xx.c utility.h UART.c UART.h SysClock.c SysClock.h Stepper.c Stepper.h utility.c Servo.c Servo.h Keypad.c Keypad.h lcd.c lcd.h DriveMotor.c DriveMotor.h Encoder.c Encoder.h
software components: CMSIS:CORE 5.5.0
