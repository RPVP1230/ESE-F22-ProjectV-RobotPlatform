# Keil uVision project Group6LED.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Group6LED
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: LEDMain1.c LED1.c LEDHeader1.h startup_stm32f303xe.s system_stm32f3xx.c UART.c UART.h SysClock.c SysClock.h stepper.c stepper.h servo.c servo.h utility.h keypad.c keypad.h Systick.c Systick.h Interupt.c Interupt.h LCD.c LCD.h Drive.c Drive.h
software components: CMSIS:CORE 5.5.0
